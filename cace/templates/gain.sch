** sch_path: cace/templates/gain.sch
**.subckt gain
Vcm Vn Vmid DC CACE{Vcm}
vdd VDD GND DC CACE{vdd}
Rg Rgp Rgn CACE{Rg} m=1
Cref Vref GND 10n m=1
Vdiff Vp Vn sin(0 5m 1k) AC=1
x1 net1 net1 net1 Vout Vref Rgp Vp Rgn Vn net2 net2 net3 net3 net3 net3 net3 net3 net3 net3 net4
+ net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4
+ net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net5 GND VDD tt_um_jonathanwest3_instamp_sp2026
Vmid Vmid GND DC CACE{Vmid}
Rload Vout GND CACE{Rload} m=1
Cload Vout GND CACE{Cload} m=1
vdd1 Vref GND DC 1.2
**** begin user architecture code

.control
ac dec 10 1 10Meg
let gain = db(V(Vout))
let cutoff_db = vecmax(gain)-3.0
meas ac bw WHEN gain=cutoff_db FALL =1
meas ac max_gain MAX gain
echo $&max_gain $&bw > CACE{simpath}/CACE{filename}_CACE{N}.data
set gnuplot_terminal=png/quit
gnuplot ac gain  title 'Differential gain'  xlabel 'Freq' ylabel 'Gain dB'

quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the noise in the driver amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option rshunt=1e12


**** end user architecture code
**.ends

* expanding   symbol:  tt_um_jonathanwest3_instamp_sp2026.sym # of pins=54
** sym_path: xschem/tt_um_jonathanwest3_instamp_sp2026.sym
** sch_path: xschem/tt_um_jonathanwest3_instamp_sp2026.sch
.subckt tt_um_jonathanwest3_instamp_sp2026 clk ena rst_n ua[0] ua[1] ua[2] ua[3] ua[4] ua[5] ua[6] ua[7] ui_in[0] ui_in[1] ui_in[2] ui_in[3] ui_in[4] ui_in[5] ui_in[6] ui_in[7] uio_in[0] uio_in[1] uio_in[2] uio_in[3] uio_in[4] uio_in[5] uio_in[6] uio_in[7] uio_oe[0] uio_oe[1] uio_oe[2] uio_oe[3] uio_oe[4] uio_oe[5] uio_oe[6] uio_oe[7] uio_out[0] uio_out[1] uio_out[2] uio_out[3] uio_out[4] uio_out[5] uio_out[6] uio_out[7] uo_out[0] uo_out[1] uo_out[2] uo_out[3] uo_out[4] uo_out[5] uo_out[6] uo_out[7] VDPWR VGND VAPWR
*.ipin VGND
*.ipin VAPWR
*.opin uo_out[0]
*.opin uo_out[1]
*.opin uo_out[2]
*.opin uo_out[3]
*.opin uo_out[4]
*.opin uo_out[5]
*.opin uo_out[6]
*.opin uo_out[7]
*.opin uio_out[0]
*.opin uio_out[1]
*.opin uio_out[2]
*.opin uio_out[3]
*.opin uio_out[4]
*.opin uio_out[5]
*.opin uio_out[6]
*.opin uio_out[7]
*.iopin ui_in[7]
*.iopin clk
*.iopin ena
*.iopin rst_n
*.iopin VDPWR
*.iopin uio_oe[0]
*.iopin uio_in[0]
*.iopin ui_in[6]
*.iopin ui_in[5]
*.iopin ui_in[4]
*.iopin ui_in[3]
*.iopin ui_in[2]
*.iopin ui_in[1]
*.iopin ui_in[0]
*.iopin ua[0]
*.iopin ua[1]
*.iopin ua[2]
*.iopin ua[3]
*.iopin ua[4]
*.iopin ua[5]
*.iopin ua[6]
*.iopin ua[7]
*.iopin uio_oe[1]
*.iopin uio_oe[2]
*.iopin uio_oe[3]
*.iopin uio_oe[4]
*.iopin uio_oe[5]
*.iopin uio_oe[6]
*.iopin uio_oe[7]
*.iopin uio_in[1]
*.iopin uio_in[2]
*.iopin uio_in[3]
*.iopin uio_in[4]
*.iopin uio_in[5]
*.iopin uio_in[6]
*.iopin uio_in[7]
x5 ua[5] ua[4] ua[3] ua[2] Vmid ua[0] ua[1] VAPWR VGND instamp
XR1 Vmid VAPWR VGND sky130_fd_pr__res_high_po_0p35 L=20 mult=1 m=1
XR2 VGND Vmid VGND sky130_fd_pr__res_high_po_0p35 L=20 mult=1 m=1
R3 VGND uo_out[0] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R4 VGND uo_out[1] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R5 VGND uo_out[2] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R6 VGND uo_out[3] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R7 VGND uo_out[4] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R8 VGND uo_out[5] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R9 VGND uo_out[6] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R10 VGND uo_out[7] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R11 VGND uio_out[0] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R12 VGND uio_out[1] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R13 VGND uio_out[2] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R14 VGND uio_out[3] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R15 VGND uio_out[4] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R16 VGND uio_out[5] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R17 VGND uio_out[6] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R18 VGND uio_out[7] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R19 VGND ui_in[0] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R20 VGND ui_in[1] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R21 VGND ui_in[2] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R22 VGND ui_in[3] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R23 VGND ui_in[4] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R24 VGND ui_in[5] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R25 VGND ui_in[6] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R26 VGND ui_in[7] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R27 VGND uio_in[0] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R28 VGND uio_in[1] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R29 VGND uio_in[2] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R30 VGND uio_in[3] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R31 VGND uio_in[4] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R32 VGND uio_in[5] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R33 VGND uio_in[6] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R34 VGND uio_in[7] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R35 VGND uio_oe[0] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R36 VGND uio_oe[1] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R37 VGND uio_oe[2] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R38 VGND uio_oe[3] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R39 VGND uio_oe[4] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R40 VGND uio_oe[5] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R43 VGND uio_oe[6] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R44 VGND uio_oe[7] sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R45 VGND ena sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R46 VGND rst_n sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
R47 VGND clk sky130_fd_pr__res_generic_m3 W=1 L=1 m=1
.ends

.GLOBAL GND
.end
