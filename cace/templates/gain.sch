** sch_path: cace/templates/gain.sch
**.subckt gain
Vcm Vn Vmid DC CACE{Vcm}
vdd VDD GND DC CACE{vdd}
Rg Rgp Rgn CACE{Rg} m=1
Cref Vref GND 100n m=1
Rload Vout GND CACE{Rload} m=1
Cload Vout GND CACE{Cload} m=1
Vdiff Vp Vn sin(0 5m 1k) AC=1
x1 net1 net1 net1 Vp Rgp Rgn Vn Vout Vref net2 net2 net3 net3 net3 net3 net3 net3 net3 net3 net4
+ net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net4
+ net4 net4 net4 net4 net4 net4 net4 net4 net4 net4 net5 GND VDD tt_um_jonathanwest3_instamp_sp2026
**** begin user architecture code

.control
ac dec 10 1 10Meg
let gain = db(V(Vout))
let cutoff_db = vecmax(gain)-3.0
meas ac bw WHEN gain=cutoff_db FALL =1
meas ac max_gain MAX gain
echo $&max_gain $&bw > CACE{simpath}/CACE{filename}_CACE{N}.data
set gnuplot_terminal=png/quit
gnuplot ac gain  title 'Differential gain'  xlabel 'Freq' ylabel 'Gain dB'

quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the noise in the driver amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option rshunt=1e12


**** end user architecture code
**.ends

* expanding   symbol:  tt_um_jonathanwest3_instamp_sp2026.sym # of pins=54
** sym_path: xschem/tt_um_jonathanwest3_instamp_sp2026.sym
** sch_path: xschem/tt_um_jonathanwest3_instamp_sp2026.sch
.subckt tt_um_jonathanwest3_instamp_sp2026 clk ena rst_n ua[0] ua[1] ua[2] ua[3] ua[4] ua[5] ua[6] ua[7] ui_in[0] ui_in[1] ui_in[2] ui_in[3] ui_in[4] ui_in[5] ui_in[6] ui_in[7] uio_in[0] uio_in[1] uio_in[2] uio_in[3] uio_in[4] uio_in[5] uio_in[6] uio_in[7] uio_oe[0] uio_oe[1] uio_oe[2] uio_oe[3] uio_oe[4] uio_oe[5] uio_oe[6] uio_oe[7] uio_out[0] uio_out[1] uio_out[2] uio_out[3] uio_out[4] uio_out[5] uio_out[6] uio_out[7] uo_out[0] uo_out[1] uo_out[2] uo_out[3] uo_out[4] uo_out[5] uo_out[6] uo_out[7] VDPWR VGND VAPWR
*.ipin VGND
*.ipin VAPWR
*.opin uo_out[0]
*.opin uo_out[1]
*.opin uo_out[2]
*.opin uo_out[3]
*.opin uo_out[4]
*.opin uo_out[5]
*.opin uo_out[6]
*.opin uo_out[7]
*.opin uio_out[0]
*.opin uio_out[1]
*.opin uio_out[2]
*.opin uio_out[3]
*.opin uio_out[4]
*.opin uio_out[5]
*.opin uio_out[6]
*.opin uio_out[7]
*.iopin ui_in[7]
*.iopin clk
*.iopin ena
*.iopin rst_n
*.iopin VDPWR
*.iopin uio_oe[0]
*.iopin uio_in[0]
*.iopin ui_in[6]
*.iopin ui_in[5]
*.iopin ui_in[4]
*.iopin ui_in[3]
*.iopin ui_in[2]
*.iopin ui_in[1]
*.iopin ui_in[0]
*.iopin ua[0]
*.iopin ua[1]
*.iopin ua[2]
*.iopin ua[3]
*.iopin ua[4]
*.iopin ua[5]
*.iopin ua[6]
*.iopin ua[7]
*.iopin uio_oe[1]
*.iopin uio_oe[2]
*.iopin uio_oe[3]
*.iopin uio_oe[4]
*.iopin uio_oe[5]
*.iopin uio_oe[6]
*.iopin uio_oe[7]
*.iopin uio_in[1]
*.iopin uio_in[2]
*.iopin uio_in[3]
*.iopin uio_in[4]
*.iopin uio_in[5]
*.iopin uio_in[6]
*.iopin uio_in[7]
x5 ua[3] ua[2] ua[0] ua[1] net1 ua[4] ua[5] VAPWR VGND instamp
XR1 net1 VAPWR VGND sky130_fd_pr__res_high_po_0p35 L=4 mult=1 m=1
XR2 VGND net1 VGND sky130_fd_pr__res_high_po_0p35 L=4 mult=1 m=1
Vmeas VGND uio_out[0] 0
.save i(vmeas)
Vmeas1 VGND uio_out[1] 0
.save i(vmeas1)
Vmeas2 VGND uio_out[2] 0
.save i(vmeas2)
Vmeas3 VGND uio_out[3] 0
.save i(vmeas3)
Vmeas4 VGND uio_out[4] 0
.save i(vmeas4)
Vmeas5 VGND uio_out[5] 0
.save i(vmeas5)
Vmeas6 VGND uio_out[6] 0
.save i(vmeas6)
Vmeas7 VGND uio_out[7] 0
.save i(vmeas7)
Vmeas16 VGND uo_out[0] 0
.save i(vmeas16)
Vmeas17 VGND uo_out[1] 0
.save i(vmeas17)
Vmeas18 VGND uo_out[2] 0
.save i(vmeas18)
Vmeas19 VGND uo_out[3] 0
.save i(vmeas19)
Vmeas20 VGND uo_out[4] 0
.save i(vmeas20)
Vmeas21 VGND uo_out[5] 0
.save i(vmeas21)
Vmeas22 VGND uo_out[6] 0
.save i(vmeas22)
Vmeas23 VGND uo_out[7] 0
.save i(vmeas23)
.ends

.GLOBAL GND
.end
