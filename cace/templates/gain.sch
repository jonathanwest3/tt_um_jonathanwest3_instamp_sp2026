** sch_path: cace/templates/gain.sch
**.subckt gain
Vcm Vcm Vmid DC CACE{Vcm}
vdd VDD GND DC CACE{vdd}
x2 Vcm net2 Vin net1 Vmid Vout net3 VDD GND instamp
Rg net1 net2 CACE{Rg} m=1
Cref net3 GND 100n m=1
Rload Vout GND CACE{Rload} m=1
Cload Vout GND CACE{Cload} m=1
Vdiff Vin Vcm sin(0 5m 1k) AC=1
Vmid Vmid GND DC CACE{Vmid}
**** begin user architecture code

.control
ac dec 10 1 10Meg
let gain = db(V(Vout))
let cutoff_db = vecmax(gain)-3.0
meas ac bw WHEN gain=cutoff_db FALL =1
meas ac max_gain MAX gain
echo $&max_gain $&bw > CACE{simpath}/CACE{filename}_CACE{N}.data
set gnuplot_terminal=png/quit
gnuplot ac gain  title 'Differential gain'  xlabel 'Freq' ylabel 'Gain dB'

quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the noise in the driver amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option rshunt=1e12


**** end user architecture code
**.ends

* expanding   symbol:  instamp.sym # of pins=9
** sym_path: xschem/instamp.sym
** sch_path: xschem/instamp.sch
.subckt instamp Vn Rgn Vp Rgp Vmid Vout Vref VDD GND
*.ipin Vp
*.ipin Vn
*.opin Vout
*.opin Vref
*.ipin Rgp
*.ipin Rgn
*.ipin Vmid
*.ipin GND
*.ipin VDD
XR1 Rgp Vout3 GND sky130_fd_pr__res_high_po_0p35 L=76.36 mult=1 m=1
XR2 Rgn Vout2 GND sky130_fd_pr__res_high_po_0p35 L=76.36 mult=1 m=1
XR3 Vout2 Vn4 GND sky130_fd_pr__res_high_po_0p35 L=51.36 mult=1 m=1
XR4 Vout3 Vp4 GND sky130_fd_pr__res_high_po_0p35 L=51.36 mult=1 m=1
XR5 Vp4 Vout5 GND sky130_fd_pr__res_high_po_0p35 L=51.36 mult=1 m=1
XR6 Vn4 Vout GND sky130_fd_pr__res_high_po_0p35 L=51.36 mult=1 m=1
x6 Vref Vout3 Vp Rgp VDD GND opamp
x2 Vref Vout2 Vn Rgn VDD GND opamp
x3 Vref Vout Vp4 Vn4 VDD GND opamp
x4 Vref Vout5 Vmid Vout5 VDD GND opamp
x1 Vref GND VDD bandgap
.ends


* expanding   symbol:  opamp.sym # of pins=6
** sym_path: xschem/opamp.sym
** sch_path: xschem/opamp.sch
.subckt opamp Vref Vout Vp Vn VDD GND
*.opin Vout
*.ipin Vref
*.ipin Vp
*.ipin Vn
*.ipin GND
*.ipin VDD
XM1 Vg1 Vg1 net1 GND sky130_fd_pr__nfet_g5v0d10v5 L=2 W=3.33 nf=1 ad='int((1 + 1)/2) * 3.33 / 1 * 0.29' as='int((1
+ + 2)/2) * 3.33 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3.33 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3.33 / 1
+ + 0.29)' nrd='0.29 / 3.33 ' nrs='0.29 / 3.33 ' sa=0 sb=0 sd=0 mult=3 m=3
XM2 net1 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4 net2 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3 Vg5 Vg1 net2 GND sky130_fd_pr__nfet_g5v0d10v5 L=2 W=3.33 nf=1 ad='int((1 + 1)/2) * 3.33 / 1 * 0.29' as='int((1
+ + 2)/2) * 3.33 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3.33 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3.33 / 1
+ + 0.29)' nrd='0.29 / 3.33 ' nrs='0.29 / 3.33 ' sa=0 sb=0 sd=0 mult=3 m=3
XMr1 net6 Vref GND GND sky130_fd_pr__nfet_g5v0d10v5 L=8 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=1 m=1
XMr2 VgR2 VgR2 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=5 W=4 nf=1 ad='int((1 + 1)/2) * 4 / 1 * 0.29' as='int((1
+ + 2)/2) * 4 / 1 * 0.29' pd='2*int((1 + 1)/2) * (4 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (4 / 1 + 0.29)' nrd='0.29
+ / 4 ' nrs='0.29 / 4 ' sa=0 sb=0 sd=0 mult=1 m=1
XMr3 Vg1 VgR2 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=5 W=4 nf=1 ad='int((1 + 1)/2) * 4 / 1 * 0.29' as='int((1
+ + 2)/2) * 4 / 1 * 0.29' pd='2*int((1 + 1)/2) * (4 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (4 / 1 + 0.29)' nrd='0.29
+ / 4 ' nrs='0.29 / 4 ' sa=0 sb=0 sd=0 mult=1 m=1
XM32 net3 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=1 m=1
XM31 Vs29 Vg1 net3 GND sky130_fd_pr__nfet_g5v0d10v5 L=2 W=6.66 nf=1 ad='int((1 + 1)/2) * 6.66 / 1 * 0.29' as='int((1
+ + 2)/2) * 6.66 / 1 * 0.29' pd='2*int((1 + 1)/2) * (6.66 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (6.66 / 1
+ + 0.29)' nrd='0.29 / 6.66 ' nrs='0.29 / 6.66 ' sa=0 sb=0 sd=0 mult=3 m=3
XM15 Vg11 Vg1 Vd10 GND sky130_fd_pr__nfet_g5v0d10v5 L=2 W=14.3 nf=1 ad='int((1 + 1)/2) * 14.3 / 1 * 0.29' as='int((1
+ + 2)/2) * 14.3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (14.3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (14.3 / 1
+ + 0.29)' nrd='0.29 / 14.3 ' nrs='0.29 / 14.3 ' sa=0 sb=0 sd=0 mult=7 m=7
XM16 Vd10 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=1 m=1
XM18 Vd9 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=1 m=1
XM17 Vg28 Vg1 Vd9 GND sky130_fd_pr__nfet_g5v0d10v5 L=2 W=14.3 nf=1 ad='int((1 + 1)/2) * 14.3 / 1 * 0.29' as='int((1
+ + 2)/2) * 14.3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (14.3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (14.3 / 1
+ + 0.29)' nrd='0.29 / 14.3 ' nrs='0.29 / 14.3 ' sa=0 sb=0 sd=0 mult=7 m=7
XM20 Vg22 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29' as='int((1
+ + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 +
+ 0.29)' nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM26 Vg26 Vg26 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=5 m=5
XM25 Vd24 Vd24 Vg26 GND sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=5 m=5
XM23 Vg27 Vd24 Vg28 GND sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=5 m=5
XM28 Vout Vg28 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=15 m=15
XM30 Vd30 Vn Vs29 GND sky130_fd_pr__nfet_g5v0d10v5 L=1.5 W=11.11 nf=1 ad='int((1 + 1)/2) * 11.11 / 1
+ * 0.29' as='int((1 + 2)/2) * 11.11 / 1 * 0.29' pd='2*int((1 + 1)/2) * (11.11 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (11.11 / 1 + 0.29)' nrd='0.29 / 11.11 ' nrs='0.29 / 11.11 ' sa=0 sb=0 sd=0 mult=9 m=9
XM29 Vd29 Vp Vs29 GND sky130_fd_pr__nfet_g5v0d10v5 L=1.5 W=11.11 nf=1 ad='int((1 + 1)/2) * 11.11 / 1
+ * 0.29' as='int((1 + 2)/2) * 11.11 / 1 * 0.29' pd='2*int((1 + 1)/2) * (11.11 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (11.11 / 1 + 0.29)' nrd='0.29 / 11.11 ' nrs='0.29 / 11.11 ' sa=0 sb=0 sd=0 mult=9 m=9
XM5 net4 Vg5 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=5 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=3 m=3
XM6 Vg5 Vg5 net4 VDD sky130_fd_pr__pfet_g5v0d10v5 L=2 W=6.6 nf=1 ad='int((1 + 1)/2) * 6.6 / 1 * 0.29' as='int((1
+ + 2)/2) * 6.6 / 1 * 0.29' pd='2*int((1 + 1)/2) * (6.6 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (6.6 / 1 +
+ 0.29)' nrd='0.29 / 6.6 ' nrs='0.29 / 6.6 ' sa=0 sb=0 sd=0 mult=3 m=3
XM7 net5 Vg5 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=3 m=3
XM8 Vd8 Vg5 net5 VDD sky130_fd_pr__pfet_g5v0d10v5 L=2 W=13.2 nf=1 ad='int((1 + 1)/2) * 13.2 / 1 * 0.29' as='int((1
+ + 2)/2) * 13.2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (13.2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (13.2 / 1
+ + 0.29)' nrd='0.29 / 13.2 ' nrs='0.29 / 13.2 ' sa=0 sb=0 sd=0 mult=3 m=3
XM09 Vd9 Vp Vd8 Vd8 sky130_fd_pr__pfet_g5v0d10v5 L=1.5 W=22.22 nf=1 ad='int((1 + 1)/2) * 22.22 / 1 *
+ 0.29' as='int((1 + 2)/2) * 22.22 / 1 * 0.29' pd='2*int((1 + 1)/2) * (22.22 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (22.22 / 1 + 0.29)' nrd='0.29 / 22.22 ' nrs='0.29 / 22.22 ' sa=0 sb=0 sd=0 mult=9 m=9
XM010 Vd10 Vn Vd8 Vd8 sky130_fd_pr__pfet_g5v0d10v5 L=1.5 W=22.22 nf=1 ad='int((1 + 1)/2) * 22.22 / 1
+ * 0.29' as='int((1 + 2)/2) * 22.22 / 1 * 0.29' pd='2*int((1 + 1)/2) * (22.22 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (22.22 / 1 + 0.29)' nrd='0.29 / 22.22 ' nrs='0.29 / 22.22 ' sa=0 sb=0 sd=0 mult=9 m=9
XM13 Vd29 Vg11 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=2.5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=5 m=5
XM14 Vg27 Vg11 Vd29 VDD sky130_fd_pr__pfet_g5v0d10v5 L=1 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=5 m=5
XM11 Vd30 Vg11 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=2.5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=5 m=5
XM12 Vg11 Vg11 Vd30 VDD sky130_fd_pr__pfet_g5v0d10v5 L=1 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=5 m=5
XM021 Vg21 Vg21 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=15 nf=1 ad='int((1 + 1)/2) * 15 / 1 * 0.29' as='int((1
+ + 2)/2) * 15 / 1 * 0.29' pd='2*int((1 + 1)/2) * (15 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (15 / 1 + 0.29)' nrd='0.29
+ / 15 ' nrs='0.29 / 15 ' sa=0 sb=0 sd=0 mult=5 m=5
XM022 Vg22 Vg22 Vg21 VDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=15 nf=1 ad='int((1 + 1)/2) * 15 / 1 * 0.29' as='int((1
+ + 2)/2) * 15 / 1 * 0.29' pd='2*int((1 + 1)/2) * (15 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (15 / 1 + 0.29)' nrd='0.29
+ / 15 ' nrs='0.29 / 15 ' sa=0 sb=0 sd=0 mult=5 m=5
XM24 Vd24 Vg5 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=5 W=4 nf=1 ad='int((1 + 1)/2) * 4 / 1 * 0.29' as='int((1
+ + 2)/2) * 4 / 1 * 0.29' pd='2*int((1 + 1)/2) * (4 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (4 / 1 + 0.29)' nrd='0.29
+ / 4 ' nrs='0.29 / 4 ' sa=0 sb=0 sd=0 mult=1 m=1
XM27 Vout Vg27 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=15 nf=1 ad='int((1 + 1)/2) * 15 / 1 * 0.29' as='int((1
+ + 2)/2) * 15 / 1 * 0.29' pd='2*int((1 + 1)/2) * (15 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (15 / 1 + 0.29)' nrd='0.29
+ / 15 ' nrs='0.29 / 15 ' sa=0 sb=0 sd=0 mult=25 m=25
XM19 Vg28 Vg22 Vg27 VDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=15 m=15
Vmeas_Iref VgR2 net6 0
.save i(vmeas_iref)
XC1 Vg27 Vout sky130_fd_pr__cap_mim_m3_1 W=30 L=20 MF=4 m=4
XC2 Vg28 Vout sky130_fd_pr__cap_mim_m3_1 W=30 L=20 MF=4 m=4
.ends


* expanding   symbol:  bandgap.sym # of pins=3
** sym_path: xschem/bandgap.sym
** sch_path: xschem/bandgap.sch
.subckt bandgap Vref GND VDD
*.opin Vref
*.ipin GND
*.ipin VDD
XM4 Vg3 Vg3 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=1 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XQ1 GND GND Ve1 sky130_fd_pr__pnp_05v5_W3p40L3p40 m=24
XQ2 GND GND Vg2 sky130_fd_pr__pnp_05v5_W3p40L3p40 m=1
XM1 Vg10 Vg1 net1 net1 sky130_fd_pr__pfet_g5v0d10v5 L=1 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2 Vg3 Vg2 net1 net1 sky130_fd_pr__pfet_g5v0d10v5 L=1 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XM11 net1 Vg5 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1
+ + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29
+ / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3 Vg10 Vg3 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=1 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XM10 net2 Vg10 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=1 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XM8 Vg12 Vg5 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1
+ + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29
+ / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM5 Vg5 Vg5 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=1 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1
+ + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29
+ / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XM12 Vref Vg12 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XM9 Vg12 Vref net2 GND sky130_fd_pr__nfet_g5v0d10v5 L=1 W=20 nf=1 ad='int((1 + 1)/2) * 20 / 1 * 0.29' as='int((1
+ + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (20 / 1 + 0.29)' nrd='0.29
+ / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7a Vg12 Vg12 net6 GND sky130_fd_pr__nfet_g5v0d10v5 L=10 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29' as='int((1
+ + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 +
+ 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7b net6 Vg12 net5 GND sky130_fd_pr__nfet_g5v0d10v5 L=10 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29' as='int((1
+ + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 +
+ 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7c net5 Vg12 net4 GND sky130_fd_pr__nfet_g5v0d10v5 L=10 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29' as='int((1
+ + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 +
+ 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7d net4 Vg12 net3 GND sky130_fd_pr__nfet_g5v0d10v5 L=10 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29' as='int((1
+ + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 +
+ 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7e net3 Vg12 net11 GND sky130_fd_pr__nfet_g5v0d10v5 L=10 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 *
+ 0.29' as='int((1 + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2)
+ * (0.5 / 1 + 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM6 Vg5 Vref Vs5 GND sky130_fd_pr__nfet_g5v0d10v5 L=1 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=1 m=1
XR1 Vg2 Vref GND sky130_fd_pr__res_high_po_0p35 L=20.1 mult=1 m=1
XR2 Vg1 Vref GND sky130_fd_pr__res_high_po_0p35 L=20.1 mult=1 m=1
XR4 GND Vs5 GND sky130_fd_pr__res_high_po_0p35 L=49.12 mult=1 m=1
XM7f net11 Vg12 net10 GND sky130_fd_pr__nfet_g5v0d10v5 L=10 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 *
+ 0.29' as='int((1 + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2)
+ * (0.5 / 1 + 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7g net10 Vg12 net9 GND sky130_fd_pr__nfet_g5v0d10v5 L=10 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 *
+ 0.29' as='int((1 + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2)
+ * (0.5 / 1 + 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7h net9 Vg12 net8 GND sky130_fd_pr__nfet_g5v0d10v5 L=10 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29' as='int((1
+ + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 +
+ 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7I net8 Vg12 net7 GND sky130_fd_pr__nfet_g5v0d10v5 L=10 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29' as='int((1
+ + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 +
+ 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM7J net7 Vg12 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=10 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29' as='int((1
+ + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 +
+ 0.29)' nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XR3 Ve1 Vg1 GND sky130_fd_pr__res_high_po_0p69 L=6.99 mult=1 m=1
.ends

.GLOBAL GND
.GLOBAL VDD
.end
