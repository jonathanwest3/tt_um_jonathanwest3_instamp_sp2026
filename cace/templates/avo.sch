** sch_path: cace/templates/avo.sch
**.subckt avo
VVcm Vcm GND DC CACE{Vcm}
Vvdd VDD GND DC CACE{Vvdd}
VVdiff Vin Vcm DC 0 AC 1
x1 Vcm net2 Vin net1 Vcm Vout net3 VDD GND instamp
Rg net1 net2 CACE{Rg} m=1
C1 net3 GND 100n m=1
Rload Vout GND 1Meg m=1
C2 Vout GND 100n m=1
**** begin user architecture code

.control
* Open loop gain measured from 100 Hz to 100kHz
ac dec 100 1 1Meg
let gain = db(V(Vout))
meas ac max_gain MAX gain
echo $&max_gain > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the noise in the driver amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option rshunt=1e12


**** end user architecture code
**.ends
.GLOBAL GND
.end
