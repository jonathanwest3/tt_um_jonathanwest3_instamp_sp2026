** sch_path: cace/templates/noise_opamp.sch
**.subckt noise_opamp
vdd VDD GND DC CACE{vdd}
Rload Vout GND CACE{Rload} m=1
Cload Vout GND CACE{Cload} m=1
Vdiff Vdiff Vmid sin(0 5m 1k) AC=1
x1 net3 Vout Vdiff net1 VDD GND opamp
vmid Vmid GND DC CACE{vmid}
Rfb net2 net1 CACE{Rfb} m=1
Rgnd Vmid net1 CACE{Rgnd} m=1
Lfb Vout net2 CACE{Lfb} m=1
**** begin user architecture code


.option sparse
.control
set gnuplot_terminal=png/quit
alter Vdiff ac=1
alter Vcm ac=0
alter Vdd ac=0
noise V(Vout) Vdiff dec 10 1 1Meg

gnuplot noise noise1.onoise_spectrum  title 'Output Noise Spectrum'  xlabel 'Freq' ylabel 'Noise V/root(Hz)'

echo $&onoise_total > CACE{simpath}/CACE{filename}_CACE{N}.data

quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the noise in the driver amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option rshunt=1e12


**** end user architecture code
**.ends

* expanding   symbol:  opamp.sym # of pins=6
** sym_path: xschem/opamp.sym
** sch_path: xschem/opamp.sch
.subckt opamp Vref Vout Vp Vn VDD GND
*.opin Vout
*.ipin Vref
*.ipin Vp
*.ipin Vn
*.ipin GND
*.ipin VDD
XM1 Vg1 Vg1 net1 GND sky130_fd_pr__nfet_g5v0d10v5 L=2 W=3.33 nf=1 ad='int((1 + 1)/2) * 3.33 / 1 * 0.29' as='int((1
+ + 2)/2) * 3.33 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3.33 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3.33 / 1
+ + 0.29)' nrd='0.29 / 3.33 ' nrs='0.29 / 3.33 ' sa=0 sb=0 sd=0 mult=3 m=3
XM2 net1 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM4 net2 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM3 Vg5 Vg1 net2 GND sky130_fd_pr__nfet_g5v0d10v5 L=2 W=3.33 nf=1 ad='int((1 + 1)/2) * 3.33 / 1 * 0.29' as='int((1
+ + 2)/2) * 3.33 / 1 * 0.29' pd='2*int((1 + 1)/2) * (3.33 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (3.33 / 1
+ + 0.29)' nrd='0.29 / 3.33 ' nrs='0.29 / 3.33 ' sa=0 sb=0 sd=0 mult=3 m=3
XMr1 net6 Vref GND GND sky130_fd_pr__nfet_g5v0d10v5 L=8 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=1 m=1
XMr2 VgR2 VgR2 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=5 W=4 nf=1 ad='int((1 + 1)/2) * 4 / 1 * 0.29' as='int((1
+ + 2)/2) * 4 / 1 * 0.29' pd='2*int((1 + 1)/2) * (4 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (4 / 1 + 0.29)' nrd='0.29
+ / 4 ' nrs='0.29 / 4 ' sa=0 sb=0 sd=0 mult=1 m=1
XMr3 Vg1 VgR2 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=5 W=4 nf=1 ad='int((1 + 1)/2) * 4 / 1 * 0.29' as='int((1
+ + 2)/2) * 4 / 1 * 0.29' pd='2*int((1 + 1)/2) * (4 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (4 / 1 + 0.29)' nrd='0.29
+ / 4 ' nrs='0.29 / 4 ' sa=0 sb=0 sd=0 mult=1 m=1
XM32 net3 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=1 m=1
XM31 Vs29 Vg1 net3 GND sky130_fd_pr__nfet_g5v0d10v5 L=2 W=6.66 nf=1 ad='int((1 + 1)/2) * 6.66 / 1 * 0.29' as='int((1
+ + 2)/2) * 6.66 / 1 * 0.29' pd='2*int((1 + 1)/2) * (6.66 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (6.66 / 1
+ + 0.29)' nrd='0.29 / 6.66 ' nrs='0.29 / 6.66 ' sa=0 sb=0 sd=0 mult=3 m=3
XM15 Vg11 Vg1 Vd10 GND sky130_fd_pr__nfet_g5v0d10v5 L=2 W=14.3 nf=1 ad='int((1 + 1)/2) * 14.3 / 1 * 0.29' as='int((1
+ + 2)/2) * 14.3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (14.3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (14.3 / 1
+ + 0.29)' nrd='0.29 / 14.3 ' nrs='0.29 / 14.3 ' sa=0 sb=0 sd=0 mult=7 m=7
XM16 Vd10 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=1 m=1
XM18 Vd9 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=1 m=1
XM17 Vg28 Vg1 Vd9 GND sky130_fd_pr__nfet_g5v0d10v5 L=2 W=14.3 nf=1 ad='int((1 + 1)/2) * 14.3 / 1 * 0.29' as='int((1
+ + 2)/2) * 14.3 / 1 * 0.29' pd='2*int((1 + 1)/2) * (14.3 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (14.3 / 1
+ + 0.29)' nrd='0.29 / 14.3 ' nrs='0.29 / 14.3 ' sa=0 sb=0 sd=0 mult=7 m=7
XM20 Vg22 Vg1 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29' as='int((1
+ + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 +
+ 0.29)' nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
XM26 Vg26 Vg26 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=5 m=5
XM25 Vd24 Vd24 Vg26 GND sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=5 m=5
XM23 Vg27 Vd24 Vg28 GND sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=5 m=5
XM28 Vout Vg28 GND GND sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=15 m=15
XM30 Vd30 Vn Vs29 GND sky130_fd_pr__nfet_g5v0d10v5 L=1.5 W=11.11 nf=1 ad='int((1 + 1)/2) * 11.11 / 1
+ * 0.29' as='int((1 + 2)/2) * 11.11 / 1 * 0.29' pd='2*int((1 + 1)/2) * (11.11 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (11.11 / 1 + 0.29)' nrd='0.29 / 11.11 ' nrs='0.29 / 11.11 ' sa=0 sb=0 sd=0 mult=9 m=9
XM29 Vd29 Vp Vs29 GND sky130_fd_pr__nfet_g5v0d10v5 L=1.5 W=11.11 nf=1 ad='int((1 + 1)/2) * 11.11 / 1
+ * 0.29' as='int((1 + 2)/2) * 11.11 / 1 * 0.29' pd='2*int((1 + 1)/2) * (11.11 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (11.11 / 1 + 0.29)' nrd='0.29 / 11.11 ' nrs='0.29 / 11.11 ' sa=0 sb=0 sd=0 mult=9 m=9
XM5 net4 Vg5 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=5 W=5 nf=1 ad='int((1 + 1)/2) * 5 / 1 * 0.29' as='int((1
+ + 2)/2) * 5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (5 / 1 + 0.29)' nrd='0.29
+ / 5 ' nrs='0.29 / 5 ' sa=0 sb=0 sd=0 mult=3 m=3
XM6 Vg5 Vg5 net4 VDD sky130_fd_pr__pfet_g5v0d10v5 L=2 W=6.6 nf=1 ad='int((1 + 1)/2) * 6.6 / 1 * 0.29' as='int((1
+ + 2)/2) * 6.6 / 1 * 0.29' pd='2*int((1 + 1)/2) * (6.6 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (6.6 / 1 +
+ 0.29)' nrd='0.29 / 6.6 ' nrs='0.29 / 6.6 ' sa=0 sb=0 sd=0 mult=3 m=3
XM7 net5 Vg5 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=3 m=3
XM8 Vd8 Vg5 net5 VDD sky130_fd_pr__pfet_g5v0d10v5 L=2 W=13.2 nf=1 ad='int((1 + 1)/2) * 13.2 / 1 * 0.29' as='int((1
+ + 2)/2) * 13.2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (13.2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (13.2 / 1
+ + 0.29)' nrd='0.29 / 13.2 ' nrs='0.29 / 13.2 ' sa=0 sb=0 sd=0 mult=3 m=3
XM09 Vd9 Vp Vd8 Vd8 sky130_fd_pr__pfet_g5v0d10v5 L=1.5 W=22.22 nf=1 ad='int((1 + 1)/2) * 22.22 / 1 *
+ 0.29' as='int((1 + 2)/2) * 22.22 / 1 * 0.29' pd='2*int((1 + 1)/2) * (22.22 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (22.22 / 1 + 0.29)' nrd='0.29 / 22.22 ' nrs='0.29 / 22.22 ' sa=0 sb=0 sd=0 mult=9 m=9
XM010 Vd10 Vn Vd8 Vd8 sky130_fd_pr__pfet_g5v0d10v5 L=1.5 W=22.22 nf=1 ad='int((1 + 1)/2) * 22.22 / 1
+ * 0.29' as='int((1 + 2)/2) * 22.22 / 1 * 0.29' pd='2*int((1 + 1)/2) * (22.22 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (22.22 / 1 + 0.29)' nrd='0.29 / 22.22 ' nrs='0.29 / 22.22 ' sa=0 sb=0 sd=0 mult=9 m=9
XM13 Vd29 Vg11 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=2.5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=5 m=5
XM14 Vg27 Vg11 Vd29 VDD sky130_fd_pr__pfet_g5v0d10v5 L=1 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=5 m=5
XM11 Vd30 Vg11 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=2.5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=5 m=5
XM12 Vg11 Vg11 Vd30 VDD sky130_fd_pr__pfet_g5v0d10v5 L=1 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=5 m=5
XM021 Vg21 Vg21 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=15 nf=1 ad='int((1 + 1)/2) * 15 / 1 * 0.29' as='int((1
+ + 2)/2) * 15 / 1 * 0.29' pd='2*int((1 + 1)/2) * (15 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (15 / 1 + 0.29)' nrd='0.29
+ / 15 ' nrs='0.29 / 15 ' sa=0 sb=0 sd=0 mult=5 m=5
XM022 Vg22 Vg22 Vg21 VDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=15 nf=1 ad='int((1 + 1)/2) * 15 / 1 * 0.29' as='int((1
+ + 2)/2) * 15 / 1 * 0.29' pd='2*int((1 + 1)/2) * (15 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (15 / 1 + 0.29)' nrd='0.29
+ / 15 ' nrs='0.29 / 15 ' sa=0 sb=0 sd=0 mult=5 m=5
XM24 Vd24 Vg5 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=5 W=4 nf=1 ad='int((1 + 1)/2) * 4 / 1 * 0.29' as='int((1
+ + 2)/2) * 4 / 1 * 0.29' pd='2*int((1 + 1)/2) * (4 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (4 / 1 + 0.29)' nrd='0.29
+ / 4 ' nrs='0.29 / 4 ' sa=0 sb=0 sd=0 mult=1 m=1
XM27 Vout Vg27 VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=15 nf=1 ad='int((1 + 1)/2) * 15 / 1 * 0.29' as='int((1
+ + 2)/2) * 15 / 1 * 0.29' pd='2*int((1 + 1)/2) * (15 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (15 / 1 + 0.29)' nrd='0.29
+ / 15 ' nrs='0.29 / 15 ' sa=0 sb=0 sd=0 mult=25 m=25
XM19 Vg28 Vg22 Vg27 VDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=10 nf=1 ad='int((1 + 1)/2) * 10 / 1 * 0.29' as='int((1
+ + 2)/2) * 10 / 1 * 0.29' pd='2*int((1 + 1)/2) * (10 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (10 / 1 + 0.29)' nrd='0.29
+ / 10 ' nrs='0.29 / 10 ' sa=0 sb=0 sd=0 mult=15 m=15
Vmeas_Iref VgR2 net6 0
.save i(vmeas_iref)
XC1 Vg27 Vout sky130_fd_pr__cap_mim_m3_1 W=30 L=20 MF=4 m=4
XC2 Vg28 Vout sky130_fd_pr__cap_mim_m3_1 W=30 L=20 MF=4 m=4
.ends

.GLOBAL GND
.GLOBAL VDD
.end
