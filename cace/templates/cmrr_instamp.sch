** sch_path: cace/templates/cmrr_instamp.sch
**.subckt cmrr_instamp
Vcm Vcm Vmid DC CACE{Vcm}
vdd VDD GND DC CACE{vdd}
Rg net1 net2 CACE{Rg} m=1
Cref net3 GND 100n m=1
Rload Vout GND CACE{Rload} m=1
Cload Vout GND CACE{Cload} m=1
Vdiff Vin Vcm sin(0 5m 1k) AC=1
x1 Vcm net2 Vin net1 Vmid Vout net3 VDD GND instamp
vmid Vmid GND DC CACE{vmid}
**** begin user architecture code

.control
set gnuplot_terminal=png/quit
alter Vdiff ac=1
alter Vcm ac=0
alter Vdd ac=0
ac dec 100 1 1Meg
let gain = db(V(Vout))
meas ac adiff FIND gain AT=1k

gnuplot Adiff gain  title 'Differential gain'  xlabel 'Freq' ylabel 'Gain dB'

alter Vdiff ac=0
alter Vcm ac=1
alter Vdd ac=0
ac dec 100 1 1Meg
let gain = db(V(Vout))
meas ac acm FIND gain AT=1k

gnuplot Acm gain  title 'Common mode gain'  xlabel 'Freq' ylabel 'Gain dB'

alter Vdiff ac=0
alter Vcm ac=0
alter Vdd ac=1
ac dec 100 1 1Meg
let gain = db(V(Vout))
meas ac avdd FIND gain AT=1k

gnuplot Avdd gain  title 'Power supply gain'  xlabel 'Freq' ylabel 'Gain dB'

let CMRR = ac1.Adiff-ac2.Acm
let PSRR = ac1.Adiff-Avdd
echo $&CMRR $&PSRR > CACE{simpath}/CACE{filename}_CACE{N}.data

quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the noise in the driver amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option rshunt=1e12


**** end user architecture code
**.ends
.GLOBAL GND
.end
