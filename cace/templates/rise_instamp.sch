** sch_path: cace/templates/rise_instamp.sch
**.subckt rise_instamp
Vcm Vcm Vmid DC CACE{Vcm}
vdd VDD GND DC CACE{vdd}
Rg net1 net2 CACE{Rg} m=1
Cref net3 GND 100n m=1
Rload Vout GND CACE{Rload} m=1
Cload Vout GND CACE{Cload} m=1
Vdiff Vin Vcm sin(0 5m 1k) AC=1
x1 Vcm net2 Vin net1 Vmid Vout net3 VDD GND instamp
vmid Vmid GND DC CACE{vmid}
**** begin user architecture code

.control
let per=5u
let t_vl=per/2
let t_vh=per*1.5
let tstop=per*3
let tstep=per/100
alter Rg=90k
alter @Vdiff[pulse] [ 0 100m $&per 1n 1n $&per $&tstop ]
tran $&tstep $&tstop
plot V(Vin,vcm) V(vout,vcm)
meas tran v_min MIN V(Vout)
meas tran v_max MAX V(Vout)
meas tran vl FIND V(Vout) AT='t_vl'
meas tran vh FIND V(Vout) AT='t_vh'
meas tran v_pp PP V(Vout)
let v_high=(0.9*v_pp)+v_min
let v_low=(0.1*v_pp)+v_min
meas tran rise_time TRIG v(Vout) VAL='v_low' rise=1 targ v(vout) Val='v_high' RISE=1
meas tran fall_time TRIG v(Vout) VAL='v_high' fall=1 targ v(vout) Val='v_low' FALL=1
let sr_rise=(v_high-v_low)/rise_time
let sr_fall=(v_high-v_low)/fall_time
let over=v_max-vh
let under=vl-v_min
let sup_current = -i(Vdd)
meas tran ivdd AVG sup_current from=0 to='per'

set gnuplot_terminal=png/quit
gnuplot v_rise_fall V(vin,vcm) V(Vout,vcm)  title 'Rise and Fall Times'  xlabel 'Time (s)' ylabel 'Volts'

echo $&rise_time $&fall_time $&sr_rise $&sr_fall $&over $&under $&ivdd> CACE{simpath}/CACE{filename}_CACE{N}.data

quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the noise in the driver amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option rshunt=1e12


**** end user architecture code
**.ends
.GLOBAL GND
.end
