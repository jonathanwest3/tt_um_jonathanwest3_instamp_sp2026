** sch_path: cace/templates/gain_instamp.sch
**.subckt gain_instamp
Vcm Vcm Vmid DC CACE{Vcm}
vdd VDD GND DC CACE{vdd}
Rg net1 net2 CACE{Rg} m=1
Cref net3 GND 100n m=1
Rload Vout GND CACE{Rload} m=1
Cload Vout GND CACE{Cload} m=1
Vdiff Vin Vcm sin(0 5m 1k) AC=1
x1 Vcm net2 Vin net1 Vmid Vout net3 VDD GND instamp
vmid Vmid GND DC CACE{vmid}
vdd1 net3 GND DC 1.2
**** begin user architecture code

.control
ac dec 10 1 10Meg
let gain = db(V(Vout))
let cutoff_db = vecmax(gain)-3.0
meas ac bw WHEN gain=cutoff_db FALL =1
meas ac max_gain MAX gain
echo $&max_gain $&bw > CACE{simpath}/CACE{filename}_CACE{N}.data
set gnuplot_terminal=png/quit
gnuplot ac gain  title 'Differential gain'  xlabel 'Freq' ylabel 'Gain dB'

quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the noise in the driver amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option rshunt=1e12


**** end user architecture code
**.ends
.GLOBAL GND
.end
